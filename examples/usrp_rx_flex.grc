options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_rx_flex
    output_language: python
    title: USRP FLEX Pager Receiver (Single Channel)
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: band_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tabwidget@0: 0, 0, 1, 1'
    label: Band Freq.
    type: real
    value: saved_band_freq
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabwidget@0: 0, 1, 1, 1'
    label: Channel
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '120'
    value: saved_channel
  states: {}
- name: channel_decim
  id: variable
  parameters:
    value: int(sample_rate/channel_rate)
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: 8*3200
  states: {}
- name: channel_taps
  id: variable
  parameters:
    value: firdes.low_pass(10, sample_rate, passband/2.0, (channel_rate-passband)/2.0)
  states: {}
- name: config_filename
  id: variable
  parameters:
    value: os.environ["HOME"]+"/.gnuradio/config.conf"
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: freq
  id: variable
  parameters:
    value: band_freq+(channel-61)*25e3
  states: {}
- name: nchan_taps
  id: variable
  parameters:
    value: len(channel_taps)
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabwidget@0: 0, 3, 1, 1'
    label: Freq Offset
    orient: Qt.Horizontal
    start: '-12.5e3'
    step: 25e3/200
    stop: 12.5e3
    value: saved_offset
  states: {}
- name: passband
  id: variable
  parameters:
    value: 2*(deviation+symbol_rate)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabwidget@0: 0, 4, 1, 1'
    label: Analog RX Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: saved_rx_gain
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: adc_rate/decim
  states: {}
- name: saved_band_freq
  id: variable_config
  parameters:
    config_file: config_filename
    option: band_center
    section: gr-pager
    type: real
    value: 930.5125e6
    writeback: band_freq
  states: {}
- name: saved_channel
  id: variable_config
  parameters:
    config_file: config_filename
    option: channel
    section: gr-pager
    type: int
    value: '25'
    writeback: channel
  states: {}
- name: saved_offset
  id: variable_config
  parameters:
    config_file: config_filename
    option: freq_offset
    section: gr-pager
    type: real
    value: '0'
    writeback: offset
  states: {}
- name: saved_rx_gain
  id: variable_config
  parameters:
    config_file: config_filename
    option: rx_gain
    section: gr-pager
    type: int
    value: '40'
    writeback: rx_gain
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tabwidget@0: 0, 2, 1, 1'
    label: Channel Freq
    type: real
    value: freq
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: flex_pager_receiver_0
  id: flex_pager_receiver
  parameters:
    frequency: freq
    sample_rate: channel_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (freq-band_freq)+offset
    decim: channel_decim
    samp_rate: sample_rate
    taps: channel_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os, math
  states: {}
- name: pager_msg_table_0
  id: pager_msg_table
  parameters:
    columns: '[''capcode'', ''frequency'', ''type'']'
    gui_hint: 'tabwidget@2: 0, 0, 1, 1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: sample_rate
    fc: band_freq
    fftsize: '4096'
    gui_hint: 'tabwidget@0: 1, 0, 2, 5'
    legend: 'False'
    name: '"Full Band Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: baseband_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 'tabwidget@1: 0, 0, 1, 1'
    name: '"Baseband"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'tabwidget@1: 0, 1, 1, 1'
    name: '"FM Demod"'
    size: '1024'
    srate: baseband_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'tabwidget@1: 1, 0, 1, 1'
    name: '"Slicer Output"'
    size: '1024'
    srate: baseband_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: band_freq
    fftsize: '4096'
    gui_hint: 'tabwidget@0: 3, 0, 4, 5'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: tabwidget
  id: qtgui_tab_widget
  parameters:
    label0: RX Spectrum
    label1: Baseband
    label2: Pages
    num_tabs: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: band_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [flex_pager_receiver_0, '0', qtgui_freq_sink_x_1, '0']
- [flex_pager_receiver_0, '1', qtgui_time_sink_x_0, '0']
- [flex_pager_receiver_0, '2', blocks_char_to_float_0, '0']
- [flex_pager_receiver_0, pages, pager_msg_table_0, pdus]
- [freq_xlating_fir_filter_xxx_0, '0', flex_pager_receiver_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
